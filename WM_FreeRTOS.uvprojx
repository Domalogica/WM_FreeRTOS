# Keil uVision project WM_FreeRTOS.uvprojx, settings and files
target WM_FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WM_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\WM_FreeRTOS;.\CMSIS\inc;.\Code\inc;.\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./CMSIS/src/: system_stm32f1xx.c
  group Startup
    ./Startup/: startup_stm32f103xe.s
  group Code
    ./Code/src/: main.c gpio_user.c error_handler.c utils.c lcd_display.c system_init.c uart.c spi.c rgb.c fml.c power_switch.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
